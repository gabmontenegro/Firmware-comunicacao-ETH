# Keil uVision project uart_to_ethernet.uvprojx, settings and files
target STM32F103VC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Blink_LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DMBED_BUILD_TIMESTAMP=1536004707.5 --split_sections -D__ASSERT_MSG -DTARGET_STM32F1 --no_rtti -DTARGET_STM32F103RB -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DTARGET_NUCLEO_F103RB -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M3 --apcs=interwork -DTARGET_FF_MORPHO -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_FAMILY_STM32 -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_SERIAL=1 -DTARGET_M3 -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .;mbed/.;mbed/TARGET_NUCLEO_F103RB;mbed/TARGET_NUCLEO_F103RB/TARGET_STM;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device;mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/device;mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;.\SerialConnect;.\eeprom_flash;.\DS1820;.\DS1820\OneWire;.\EthernetConnect;.\WIZnetInterface;.\WIZnetInterface\DHCPClient;.\WIZnetInterface\DNSClient;.\WIZnetInterface\Socket;.\WIZnetInterface\WIZnet;.\GmarketComm;.\UploadFirmware;.\Sensors_Actuators
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/stm32f103xb.sct
  link misc: --show_full_path
  group STM32F103VC
    ./: main.cpp
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32f103xb.o stm32f1xx_hal.o stm32f1xx_hal_adc.o stm32f1xx_hal_adc_ex.o stm32f1xx_hal_can.o stm32f1xx_hal_cec.o stm32f1xx_hal_cortex.o stm32f1xx_hal_crc.o stm32f1xx_hal_dac.o stm32f1xx_hal_dac_ex.o stm32f1xx_hal_dma.o stm32f1xx_hal_eth.o stm32f1xx_hal_flash.o stm32f1xx_hal_flash_ex.o stm32f1xx_hal_gpio.o stm32f1xx_hal_gpio_ex.o stm32f1xx_hal_hcd.o stm32f1xx_hal_i2c.o stm32f1xx_hal_i2s.o stm32f1xx_hal_irda.o stm32f1xx_hal_iwdg.o stm32f1xx_hal_mmc.o stm32f1xx_hal_nand.o stm32f1xx_hal_nor.o stm32f1xx_hal_pccard.o stm32f1xx_hal_pcd.o stm32f1xx_hal_pcd_ex.o stm32f1xx_hal_pwr.o stm32f1xx_hal_rcc.o stm32f1xx_hal_rcc_ex.o stm32f1xx_hal_rtc.o stm32f1xx_hal_rtc_ex.o stm32f1xx_hal_sd.o stm32f1xx_hal_smartcard.o stm32f1xx_hal_spi.o stm32f1xx_hal_spi_ex.o stm32f1xx_hal_sram.o stm32f1xx_hal_tim.o stm32f1xx_hal_tim_ex.o stm32f1xx_hal_uart.o stm32f1xx_hal_usart.o stm32f1xx_hal_wwdg.o stm32f1xx_ll_adc.o stm32f1xx_ll_crc.o stm32f1xx_ll_dac.o stm32f1xx_ll_dma.o stm32f1xx_ll_exti.o stm32f1xx_ll_fsmc.o stm32f1xx_ll_gpio.o stm32f1xx_ll_i2c.o stm32f1xx_ll_pwr.o stm32f1xx_ll_rcc.o stm32f1xx_ll_rtc.o stm32f1xx_ll_sdmmc.o stm32f1xx_ll_spi.o stm32f1xx_ll_tim.o stm32f1xx_ll_usart.o stm32f1xx_ll_usb.o stm32f1xx_ll_utils.o stm_spi_api.o sys.o system_stm32f1xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_F103RB/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: objects.h PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/device/: stm32_assert_template.h stm32_hal_legacy.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.h stm32f1xx_ll_dac.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
  group SerialConnect
    ./SerialConnect/: SerialConnect.cpp
  group EthernetConnect
    ./EthernetConnect/: EthernetConnect.cpp
  group WIZnetInterface
    ./WIZnetInterface/: WIZnetInterface.cpp
    ./WIZnetInterface/DHCPClient/: DHCPClient.cpp
    ./WIZnetInterface/DNSClient/: DNSClient.cpp
    ./WIZnetInterface/Socket/: Endpoint.cpp Socket.cpp TCPSocketConnection.cpp TCPSocketServer.cpp UDPSocket.cpp
    ./WIZnetInterface/WIZnet/: W5500.cpp
  group GmarketComm
    ./GmarketComm/: GmarketComm.cpp GmarketComm.h
  group Eeprom_flash
    ./eeprom_flash/: eeprom_flash.cpp eeprom_flash.h
